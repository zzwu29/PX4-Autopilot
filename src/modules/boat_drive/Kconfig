## src/modules/boat_drive/Kconfig
```kconfig
menuconfig MODULES_BOAT_DRIVE
	bool "boat_drive"
	default n
	depends on MODULES_CONTROL_ALLOCATOR
	---help---
		Enable support for control of boats
```
